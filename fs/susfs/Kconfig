## fs/susfs/Kconfig
```kconfig
# Kconfig 完整内容
config SUSFS
    tristate "SUSFS filesystem support"
    depends on BLOCK
    help
      This is SUSFS - Simple Userspace Filesystem
```
